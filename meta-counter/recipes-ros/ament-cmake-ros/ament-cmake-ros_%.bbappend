# rmw-test-fixture-implementation пропущено разом із zenoh (лише для тестів).
ROS_EXEC_DEPENDS:remove = "rmw-test-fixture-implementation"
ROS_EXPORT_DEPENDS:remove = "rmw-test-fixture-implementation"
ROS_BUILDTOOL_EXPORT_DEPENDS:remove = "rmw-test-fixture-implementation-native"
